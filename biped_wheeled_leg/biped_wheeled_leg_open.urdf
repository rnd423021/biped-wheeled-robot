Commit message: Nice

File: biped_wheeled_leg/biped_wheeled_leg_open.urdf (robot description, URDF)
Before this commit: robot biped_wheeled_leg_open, 11 links, 10 joints
Joints:
- joint hip_pitch_joint: origin xyz=0.0 0.0 0.0 rpy=0.0 -0.0 0.0 -> xyz=0.0 0.0 0.0 rpy=0.0 0.942 0.0
